# Keil uVision project my_project_ROM.uvprojx, settings and files
target my_project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: my_project_rom
  AfterMake: fromelf --bin --output .\Build\uart_loopback_24mhz_brclk.bin .\Build\uart_loopback_24mhz_brclk.axf
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __MSP432P401R__
  c include: ../../../../../../source;../../../../../../source/third_party/CMSIS/Include/;..\sys;D:\Keil_v5\ARM\Pack\TexasInstruments\MSP432P4xx_DFP\3.2.6\Device\Include;..\hardware;..\..\ti_driverlib\simplelink_msp432p4_sdk_3_40_01_02;..\..\ti_driverlib\simplelink_msp432p4_sdk_3_40_01_02\third_party\CMSIS\Include;..\sys;..\hardware\button
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source
    ../: system_msp432p401r.c main.c
    ./: startup_msp432p401r_uvision.s
  group Library
    ../../ti_driverlib/simplelink_msp432p4_sdk_3_40_01_02/ti/devices/msp432p4xx/driverlib/keil/: msp432p4xx_driverlib.lib
  group SYS
    ../sys/: sysinit.c baudrate_calculate.c delay.c pid.c
  group HARDWARE
    ../hardware/: trans.c timer.c oled.c ic.c led.c key.c pwm.c
  group button
    ../hardware/button/: olediic.c usart.c timA.c
software components: CMSIS:CORE 4.3.0
